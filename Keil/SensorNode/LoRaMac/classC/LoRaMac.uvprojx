# Keil uVision project LoRaMac.uvprojx, settings and files
target REGION_AS923 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L073VZIx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LoRaMac +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L073xx USE_DEBUGGER HSE_VALUE=24000000 OVER_THE_AIR_ACTIVATION=1 REGION_AS923
  c include: ..\..\..\..\src;..\..\..\..\src\boards\;..\..\..\..\src\boards\mcu\stm32;..\..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\..\src\boards\mcu\stm32\STM32L0xx_HAL_Driver\Inc;..\..\..\..\src\boards\NucleoL073;..\..\..\..\src\boards\NucleoL073\cmsis;..\..\..\..\src\mac;..\..\..\..\src\mac\region;..\..\..\..\src\peripherals;..\..\..\..\src\radio;..\..\..\..\src\system;..\..\..\..\src\system\crypto
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group apps
    ../../../../src/apps/LoRaMac/classC/SensorNode/: main.c
  group boards\SensorNode
    ../../../../src/boards/NucleoL073/: adc-board.c board.c delay-board.c eeprom-board.c gpio-board.c i2c-board.c rtc-board.c spi-board.c uart-board.c sx1276mb1las-board.c
  group boards\SensorNode\cmsis
    ../../../../src/boards/NucleoL073/cmsis/arm-std/: startup_stm32l073xx.s
    ../../../../src/boards/NucleoL073/cmsis/: system_stm32l0xx.c
  group boards\SensorNode\STM32L0xx_HAL_Driver
    ../../../../src/boards/mcu/stm32/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_iwdg.c
  group boards\mcu\stm32
    ../../../../src/boards/mcu/stm32/: sysIrqHandlers.c
    ../../../../src/boards/mcu/: utilities.c
  group mac
    ../../../../src/mac/: LoRaMac.c LoRaMacCrypto.lib
  group mac\region
    ../../../../src/mac/region/: Region.c RegionCommon.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915.c RegionUS915-Hybrid.c
  group radio
    ../../../../src/radio/sx1276/: sx1276.c
  group system
    ../../../../src/system/: adc.c delay.c fifo.c gpio.c i2c.c timer.c uart.c eeprom.c
  group system\crypto
    ../../../../src/system/crypto/: aes.c cmac.c
target REGION_AU915 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L073VZIx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: as above
  output: LoRaMac +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L073xx USE_DEBUGGER HSE_VALUE=24000000 OVER_THE_AIR_ACTIVATION=1 REGION_AU915
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target REGION_CN470 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L073VZIx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: as above
  output: LoRaMac +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L073xx USE_DEBUGGER HSE_VALUE=24000000 OVER_THE_AIR_ACTIVATION=1 REGION_CN470
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target REGION_CN779 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L073VZIx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: as above
  output: LoRaMac +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L073xx USE_DEBUGGER HSE_VALUE=24000000 OVER_THE_AIR_ACTIVATION=1 REGION_CN779
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target REGION_EU433 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L073VZIx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: as above
  output: LoRaMac +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L073xx USE_DEBUGGER HSE_VALUE=24000000 OVER_THE_AIR_ACTIVATION=1 REGION_EU433
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target REGION_EU868 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L073VZIx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: as above
  output: LoRaMac +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L073xx USE_DEBUGGER HSE_VALUE=24000000 OVER_THE_AIR_ACTIVATION=1 REGION_EU868
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target REGION_KR920 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L073VZIx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: as above
  output: LoRaMac +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L073xx USE_DEBUGGER HSE_VALUE=24000000 OVER_THE_AIR_ACTIVATION=1 REGION_KR920
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target REGION_IN865 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L073VZIx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: as above
  output: LoRaMac +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L073xx USE_DEBUGGER HSE_VALUE=24000000 OVER_THE_AIR_ACTIVATION=1 REGION_IN865
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target REGION_US915 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L073VZIx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: as above
  output: LoRaMac +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L073xx USE_DEBUGGER HSE_VALUE=24000000 OVER_THE_AIR_ACTIVATION=1 REGION_US915
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target REGION_US915_HYBRID (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L073VZIx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: as above
  output: LoRaMac +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L073xx USE_DEBUGGER HSE_VALUE=24000000 OVER_THE_AIR_ACTIVATION=1 REGION_US915_HYBRID
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 4.3.0
